# Keil uVision project hc05_f407.uvprojx, settings and files
target hc05_f407 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: hc05_f407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../../Core/Inc;../../../../controller-stm32/hal-f407-uart4/CubeMX/F407_Vision_Link/Drivers/STM32F4xx_HAL_Driver/Inc;../../../../controller-stm32/hal-f407-uart4/CubeMX/F407_Vision_Link/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../controller-stm32/hal-f407-uart4/CubeMX/F407_Vision_Link/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../controller-stm32/hal-f407-uart4/CubeMX/F407_Vision_Link/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c hc05_node.c hc05_protocol_shared.c hc05_at_shared.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../controller-stm32/hal-f407-uart4/CubeMX/F407_Vision_Link/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
