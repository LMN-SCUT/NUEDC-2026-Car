# Keil uVision project STM32F407VET6.uvprojx, settings and files
target STM32F407VET6 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: STM32F407VET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F407xx
  c include: .\User;.\Device;D:\keil5\ARM\PACK\Keil\STM32F4xx_DFP\2.3.0\Drivers\CMSIS\Device\ST\STM32F4xx\Include;D:\keil5\ARM\PACK\ARM\CMSIS\5.0.1\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c timebase.c key.c motor.c encoder.c speed_pi.c motor_protection.c newgrey.c hc05.c line_follower.c
  group Device
    ./Device/: startup_stm32f407xx.s system_stm32f4xx.c
